# Keil uVision project u-boot-1.3.4-2440.uvproj, settings and files
target sdram-jlink (ARM-ADS)
  device: S3C2440A Samsung
  cpu: IRAM(0x40000000-0x40000FFF) CLOCK(12000000) CPUTYPE(ARM920T)
  output: u_boot
  AfterMake: fromelf.exe --bin -o  "$L@L.bin" ./sdram-jlink/u_boot.axf
  c flags: Optim=1
  c define: __ARM__ __KERNEL__
  c misc: --gnu --fpu=none --wrap_diagnostics
  c include: ..\u-boot\include
  memory RVCT9: RAM 0x40000000 size 0x1000
  scatter file: ..\u-boot\board\samsung\tq2440\u-boot.sct
  link misc: --no_remove
  group cpu_arm920t
    ../u-boot/cpu/arm920t/: cpu.c interrupts.c start.S
  group cpu_s3c24x0
    ../u-boot/cpu/arm920t/s3c24x0/: speed.c s3c24x0_i2c.c s3c24x0_interrupts.c s3c24x0_nand.c s3c24x0_serial.c s3c24x0_usb.c s3c24x0_usb_ohci.c
  group lib_generic
    ../u-boot/lib_generic/: crc32.c ctype.c display_options.c div64.c lmb.c string.c vsprintf.c zlib.c
  group lib_arm
    ../u-boot/lib_arm/: board.c bootm.c cache.c interrupts_lib.c
  group common
    ../u-boot/common/: cmd_bootm.c cmd_boot.c cmd_net.c cmd_nvedit.c console.c command.c flash.c devices.c env_flash.c env_common.c exports.c lists.c image.c gunzip.c usb.c main.c cmd_flash.c cmd_boot_zimage.c
  group net
    ../u-boot/net/: bootp.c eth.c net.c tftp.c nfs.c rarp.c
  group driver_net
    ../u-boot/drivers/net/: dm9000x.c
  group driver_mtd_nand
    ../u-boot/drivers/mtd/nand/: nand.c nand_base.c nand_bbt.c nand_ecc.c nand_ids.c nand_util.c
  group misc
    ../misc/: retarget.c
  group board_jz2440
    ../u-boot/board/samsung/jz2440/: boot_init.c jz2440.c jz2440_flash.c
